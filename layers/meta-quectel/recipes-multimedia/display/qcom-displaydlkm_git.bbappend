FILESPATH:prepend =  "${WORKSPACE}/sources/quectel-src:"
SRC_URI = "file://display-drivers"
S = "${WORKDIR}/display-drivers"
